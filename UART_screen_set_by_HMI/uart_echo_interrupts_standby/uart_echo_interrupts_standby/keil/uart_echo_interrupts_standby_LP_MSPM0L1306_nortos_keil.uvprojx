# Keil uVision project uart_echo_interrupts_standby_LP_MSPM0L1306_nortos_keil.uvprojx, settings and files
target uart_echo_interrupts_standby_LP_MSPM0L1306_nortos_keil (6220000::V6.22::ARMCLANG)
  device: MSPM0L1306 Texas Instruments
  pack: TexasInstruments.MSPM0L11XX_L13XX_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: uart_echo_interrupts_standby_LP_MSPM0L1306_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' uart_echo_interrupts_standby.syscfg"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L1306__
  c include: ../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\mspm0l1306.sct
  group Source
    ../: uart_echo_interrupts_standby.c uart_echo_interrupts_standby.syscfg ti_msp_dl_config.h ti_msp_dl_config.c tjc_usart_hmi.c tjc_usart_hmi.h
    ./: startup_mspm0l130x_uvision.s
  group Driverlib
    ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0l11xx_l13xx/: driverlib.a
